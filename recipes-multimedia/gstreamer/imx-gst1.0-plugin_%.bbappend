DEPENDS_append_mx6 += " libdrm"
