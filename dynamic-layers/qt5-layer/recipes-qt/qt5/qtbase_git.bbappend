PACKAGECONFIG_append = " no-opengl linuxfb accessibility fontconfig libinput tslib xkbcommon optimize-size"
PACKAGECONFIG_remove = " examples tests eglfs gles2"
