PACKAGECONFIG_append = " gstreamer"
PACKAGECONFIG_remove = " pulseaudio alsa openal"
